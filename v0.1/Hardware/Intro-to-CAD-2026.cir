.title KiCad schematic
C4 Net-_C4-Pad1_ Net-_JP19-B_ 1u
R14 Net-_JP17-B_ GND 100
TP1 __TP1
J1 __J1
TP2 __TP2
R17 Net-_U2-BCK_ /BCK 33
R16 Net-_U2-LRCK_ /WS 33
R18 Net-_U2-DOUT_ /DATA 33
U2 __U2
C11 GND Net-_U2-VREF_ 0.1u
X1 __X1
C12 VDDA GND 10u
C13 GND VDDA 0.1u
C10 GND +3.3V 0.1u
R15 Net-_X1-OUT_ /SCKI 33
R19 Net-_X1-OUT_ Net-_U2-SCKI_ 33
JP18 __JP18
C6 Net-_U2-VINL_ GND 4.7n
R2 Net-_JP18-A_ Net-_U2-VINL_ 200
C8 +3.3V GND 10u
C9 Net-_U2-VREF_ GND 10u
JP19 __JP19
R3 Net-_JP19-B_ Net-_U2-VINR_ 200
C7 Net-_U2-VINR_ GND 4.7n
C3 Net-_C3-Pad1_ Net-_JP18-A_ 1u
J7 __J7
J6 __J6
U3 __U3
J5 __J5
JP50 __JP50
J4 __J4
U7 __U7
TP12 __TP12
C20 GND Net-_TR1-C_RX_ 0.1u
TP10 __TP10
C23 GND VDDA 0.1u
TP14 __TP14
C16 Net-_U7-1B2_ GND 15n
C19 Net-_U7-1B1_ GND 15n
TP16 __TP16
U8 __U8
R8 GND Net-_U8B--_ 15
R9 Net-_U7-1B1_ Net-_U8B-+_ 15
C21 Net-_U8A--_ Net-_C21-Pad2_ 150p
C18 Net-_C18-Pad1_ Net-_U8B--_ 150p
R12 Net-_U8B--_ Net-_C18-Pad1_ 10k
R10 Net-_U7-1B2_ Net-_U8A-+_ 15
R11 GND Net-_U8A--_ 15
Je3 __Je3
JP88 __JP88
TR1 __TR1
R1 Net-_TR1-C_RX_ VDDA 10k
J11 __J11
JP85 __JP85
C1 Net-_J11-In_ Net-_JP86-A_ 1u
R4 GND Net-_TR1-C_RX_ 10k
TP11 __TP11
R13 Net-_U8A--_ Net-_C21-Pad2_ 10k
TP18 __TP18
C32 Net-_C21-Pad2_ /Q 10u
C30 GND VDDA 0.1u
J12 __J12
TP17 __TP17
C31 Net-_C18-Pad1_ /I 10u
Y2 __Y2
U4 __U4
C15 GND +3.3V 0.1u
TP4 __TP4
TP3 __TP3
J8 __J8
TP5 __TP5
FB1 __FB1
TP25 __TP25
C2 +5V GND 10u
U1 __U1
C56 Net-_U1-VOUT_ GND 10u
C55 Net-_U1-EN_ GND 0.1u
C17 VDDA GND 100u
R7 Net-_U1-VOUT_ VDDA 10
TP26 __TP26
C5 Net-_U1-EN_ GND 10u
R6 Net-_U1-SENSE/ADJ_ GND 12k
R5 Net-_U1-SENSE/ADJ_ Net-_U1-VOUT_ 33k
.end
